FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Use-correct-option-for-the-wayland_scanner.patch"

