FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Use-mesa-17.3.6-gbm.h-file.patch"

